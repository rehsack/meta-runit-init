require avahi-append.inc
