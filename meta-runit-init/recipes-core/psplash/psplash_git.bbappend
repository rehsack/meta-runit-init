require psplash-append.inc
