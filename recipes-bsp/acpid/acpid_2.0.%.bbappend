require acpid-append.inc
