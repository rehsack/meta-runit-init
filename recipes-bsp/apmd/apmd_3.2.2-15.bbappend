require apmd-append.inc
