include linux-yocto-append.inc

