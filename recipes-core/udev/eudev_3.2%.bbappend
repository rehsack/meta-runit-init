require eudev-append.inc
