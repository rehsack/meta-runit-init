FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

include busybox_append.inc
