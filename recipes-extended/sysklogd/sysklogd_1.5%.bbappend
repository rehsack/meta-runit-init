require sysklogd-append.inc
